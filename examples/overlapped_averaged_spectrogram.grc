<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>overlapped_averaged_spectrogram</value></param>
<param><key>comment</key><value>This example draws a spectrogram by calculating FFTs
with overlapped windows and then averaging the power
from multiple successive FFT windows.

It also demonstrates the convenient type conversion
block that directly works for files saved from rtl_sdr
command line tool.</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>averages</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>every_n</value></param>
<param><key>value</key><value>int(fftsize*0.7)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftsize</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2.4e6</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_1</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>rtlsdr_recording</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0_0_0</value></param>
<param><key>fft_size</key><value>fftsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.hann(fftsize)</value></param>
</block>
<block>
<key>oh2eat_int8_to_complex</key>
<param><key>id</key><value>oh2eat_int8_to_complex_0</value></param>
<param><key>input_type</key><value>0</value></param>
</block>
<block>
<key>oh2eat_stream_to_vector_overlap</key>
<param><key>id</key><value>oh2eat_stream_to_vector_overlap_0</value></param>
<param><key>every_n_items</key><value>every_n</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vecsize</key><value>fftsize</value></param>
</block>
<block>
<key>oh2eat_sum_vectors_ff</key>
<param><key>id</key><value>oh2eat_sum_vectors_ff_0</value></param>
<param><key>decimation</key><value>averages</value></param>
<param><key>scale</key><value>1.0/averages</value></param>
<param><key>vecsize</key><value>fftsize</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0</value></param>
<param><key>zmax</key><value>2</value></param>
<param><key>zmin</key><value>0</value></param>
<param><key>color1</key><value>6</value></param>
<param><key>ncols</key><value>fftsize</value></param>
<param><key>nrows</key><value>200</value></param>
<param><key>samp_rate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>zmax</key><value>2</value></param>
<param><key>zmin</key><value>0</value></param>
<param><key>color1</key><value>6</value></param>
<param><key>ncols</key><value>fftsize</value></param>
<param><key>nrows</key><value>200</value></param>
<param><key>samp_rate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_1</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_1</source_block_id><sink_block_id>oh2eat_sum_vectors_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>oh2eat_int8_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>oh2eat_stream_to_vector_overlap_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>oh2eat_int8_to_complex_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>oh2eat_stream_to_vector_overlap_0</source_block_id><sink_block_id>fft_vxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>oh2eat_sum_vectors_ff_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>oh2eat_sum_vectors_ff_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
